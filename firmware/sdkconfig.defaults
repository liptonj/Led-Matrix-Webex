## firmware/sdkconfig.defaults
```kconfig
# Disable core dump functionality to prevent partition warning
CONFIG_ESP_COREDUMP_ENABLE_TO_FLASH=n
CONFIG_ESP_COREDUMP_ENABLE_TO_UART=n
```
